# Keil uVision project Demo.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")ESEL ELITTLE FPU2
  output: Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .\..\;.\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;.\..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F0_malib\inc;..\..\..\Libraries\Utilities\STM32F3_Discovery;..\Service
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ./../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32_USB-FS-Device_Driver
    ./../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F3-Discovery
    ../../../Libraries/Utilities/STM32F3_Discovery/: stm32f3_discovery.c stm32f3_discovery_l3gd20.c stm32f3_discovery_lsm303dlhc.c
  group STM32F30x_StdPeriph_Driver
    ./../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group User
    ./../: hw_config.c main.c stm32f30x_it.c system_stm32f30x.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Malib
    ../../../Libraries/STM32F0_malib/src/: stm32f0xx_lcd.c
  group Service
    ../Service/: Init.c Gyroscope.c Fonctions.c Accelerometre.c
